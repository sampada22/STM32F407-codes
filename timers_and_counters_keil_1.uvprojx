# Keil uVision project timers_and_counters_keil_1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timers_and_counters_keil_1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\LCD\STM_MY_LCD16X2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./LCD/STM_MY_LCD16X2/: STM_MY_LCD16X2.c STM_MY_LCD16X2.h
    ./ADC_TIMER_KEIL_1/: main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 2.6.2
