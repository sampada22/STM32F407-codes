# Keil uVision project test_omni.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test_omni
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./test_omni/: main.c encoder.c encoder.h motor.c motor.h drive.c drive.h
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:CAN 1.7.4, Device:STM32Cube HAL:CRC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DAC 1.7.4, Device:STM32Cube HAL:DCMI 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:ETH 1.7.4, Device:STM32Cube HAL:Flash 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:HCD 1.7.4, Device:STM32Cube HAL:I2C 1.7.4, Device:STM32Cube HAL:I2S 1.7.4, Device:STM32Cube HAL:IRDA 1.7.4, Device:STM32Cube HAL:IWDG 1.7.4, Device:STM32Cube HAL:MMC 1.7.4, Device:STM32Cube HAL:NAND 1.7.4, Device:STM32Cube HAL:NOR 1.7.4, Device:STM32Cube HAL:PC Card 1.7.4, Device:STM32Cube HAL:PCD 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:RNG 1.7.4, Device:STM32Cube HAL:RTC 1.7.4, Device:STM32Cube HAL:SD 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:SRAM 1.7.4, Device:STM32Cube HAL:Smartcard 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:STM32Cube HAL:UART 1.7.4, Device:STM32Cube HAL:USART 1.7.4, Device:STM32Cube HAL:WWDG 1.7.4, Device:Startup 2.6.2
